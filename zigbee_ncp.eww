<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <!-- Automatically generated by Silicon Labs. -->
    <batchBuild />
    <project>
        <path>$WS_DIR$\zigbee_ncp.ewp</path>
    </project>
</workspace>
