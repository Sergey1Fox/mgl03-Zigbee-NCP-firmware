# IAR project zigbee_ncp.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1B232F256GM32 SiliconLaboratories EFR32MG1B232F256GM32
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EMBER_APS_UNICAST_MESSAGE_COUNT=32; EMBER_BINDING_TABLE_SIZE=32; EMBER_BROADCAST_TABLE_SIZE=64; EMBER_CUSTOM_MAC_FILTER_TABLE_SIZE=15; EMBER_KEY_TABLE_SIZE=12; EMBER_MAX_END_DEVICE_CHILDREN=32; EMBER_PACKET_BUFFER_COUNT=255; EMBER_SOURCE_ROUTE_TABLE_SIZE=200; EFR32MG1B232F256GM32=1; SL_APP_PROPERTIES=1; SL_COMPONENT_CATALOG_PRESENT=1; SEGGER_RTT_ALIGNMENT=1024; CORTEXM3=1; CORTEXM3_EFM32_MICRO=1; CORTEXM3_EFR32=1; PHY_RAIL=1; PLATFORM_HEADER="platform-header.h"; SL_LEGACY_HAL_ENABLE_WATCHDOG=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CLIENT=1; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0; CUSTOM_TOKEN_HEADER="sl_token_manager_af_token_header.h"; USE_NVM3=1; UC_BUILD=1; EMBER_AF_NCP=1; EMBER_SERIAL1_RTSCTS=1; EZSP_UART=1; EMBER_MULTI_NETWORK_STRIPPED=1; SL_ZIGBEE_PHY_SELECT_STACK_SUPPORT=1; SL_ZIGBEE_STACK_COMPLIANCE_REVISION=22
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$; config; autogen; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\Device\SiliconLabs\EFR32MG1B\Include; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\common\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\bootloader; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\bootloader\api; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\CMSIS\Core\Include; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\driver\debug\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\device_init\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\emdrv\dmadrv\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\emdrv\common\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\emlib\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\iostream\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\legacy_common_ash\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\legacy_hal\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\legacy_hal_wdog\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\legacy_ncp_ash\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\legacy_printf\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\security\sl_component\sl_mbedtls_support\config; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\security\sl_component\sl_mbedtls_support\config\preset; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\security\sl_component\sl_mbedtls_support\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\third_party\mbedtls\include; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\third_party\mbedtls\library; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\emdrv\nvm3\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\power_manager\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\third_party\printf; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\third_party\printf\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\security\sl_component\sl_psa_driver\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\common; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\protocol\ble; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\protocol\ieee802154; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\protocol\wmbus; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\protocol\zwave; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\chip\efr32\efr32xg1x; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\protocol\sidewalk; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin\rail_util_ieee802154; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin\pa-conversions; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin\pa-conversions\efr32xg1x; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin\rail_util_power_manager_init; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin\rail_util_pti; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin\rail_util_rssi; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\third_party\segger\systemview\SEGGER; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\silicon_labs\silabs_core\memory_manager; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\common\toolchain\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\system\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\sleeptimer\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\emdrv\tempdrv\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\service\token_manager\inc; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\framework\common; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\platform\micro; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\framework; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\framework\plugin\debug-print; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\include; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\gp; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\em260; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\xncp; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\util\ezsp; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\framework\util; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\util\security; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\zigbee; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\security; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\rail_lib\plugin; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\mac\rail_mux; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\platform\radio\mac; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\util\silicon_labs\silabs_core; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\core; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\mac; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\app\ncp\plugin\xncp; C:\SiliconLabs\SimplicityStudio\v5\offline\sdk\gecko_sdk_4.4.6\protocol\zigbee\stack\zll
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: EMBER_APS_UNICAST_MESSAGE_COUNT=32; EMBER_BINDING_TABLE_SIZE=32; EMBER_BROADCAST_TABLE_SIZE=64; EMBER_CUSTOM_MAC_FILTER_TABLE_SIZE=15; EMBER_KEY_TABLE_SIZE=12; EMBER_MAX_END_DEVICE_CHILDREN=32; EMBER_PACKET_BUFFER_COUNT=255; EMBER_SOURCE_ROUTE_TABLE_SIZE=200; SL_IOSTREAM_USART_VCOM_BAUDRATE=115200; SL_IOSTREAM_USART_VCOM_PERIPHERAL=USART0; SL_IOSTREAM_USART_VCOM_PERIPHERAL_NO=0; SL_IOSTREAM_USART_VCOM_RX_LOC=14; SL_IOSTREAM_USART_VCOM_RX_PIN=10; SL_IOSTREAM_USART_VCOM_RX_PORT=gpioPortC; SL_IOSTREAM_USART_VCOM_TX_LOC=16; SL_IOSTREAM_USART_VCOM_TX_PIN=11; SL_IOSTREAM_USART_VCOM_TX_PORT=gpioPortC; EFR32MG1B232F256GM32=1; SL_APP_PROPERTIES=1; SL_COMPONENT_CATALOG_PRESENT=1; SEGGER_RTT_ALIGNMENT=1024; CORTEXM3=1; CORTEXM3_EFM32_MICRO=1; CORTEXM3_EFR32=1; PHY_RAIL=1; PLATFORM_HEADER="platform-header.h"; SL_LEGACY_HAL_ENABLE_WATCHDOG=1; MBEDTLS_CONFIG_FILE=<sl_mbedtls_config.h>; MBEDTLS_PSA_CRYPTO_CLIENT=1; MBEDTLS_PSA_CRYPTO_CONFIG_FILE=<psa_crypto_config.h>; SL_RAIL_LIB_MULTIPROTOCOL_SUPPORT=0; SL_RAIL_UTIL_PA_CONFIG_HEADER=<sl_rail_util_pa_config.h>; RTT_USE_ASM=0; CUSTOM_TOKEN_HEADER="sl_token_manager_af_token_header.h"; USE_NVM3=1; UC_BUILD=1; EMBER_AF_NCP=1; EMBER_SERIAL1_RTSCTS=1; EZSP_UART=1; EMBER_MULTI_NETWORK_STRIPPED=1; SL_ZIGBEE_PHY_SELECT_STACK_SUPPORT=1; SL_ZIGBEE_STACK_COMPLIANCE_REVISION=22
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: zigbee_ncp.s37
  ILINK.IlinkOutputFile: zigbee_ncp.out
  ILINK.IlinkIcfFile: autogen\linkerfile.icf
  group (top)
    ./: zigbee_ncp.ipcf
  group Simplicity Configurator
    ./: app.c main.c
  group Simplicity Configurator/autogen
    autogen/: gen.properties linkerfile.icf RTE_Components.h sl_application_type.h sl_component_catalog.h sl_device_init_clocks.c sl_event_handler.c sl_event_handler.h sl_iostream_handles.c sl_iostream_handles.h sl_iostream_init_instances.h sl_iostream_init_usart_instances.c sl_iostream_init_usart_instances.h sl_power_manager_handler.c sl_rail_util_ieee802154_phy_select.c sl_rail_util_ieee802154_stack_event.c sli_mbedtls_config_autogen.h sli_mbedtls_config_transform_autogen.h sli_psa_builtin_config_autogen.h sli_psa_config_autogen.h zigbee_af_token_headers.h zigbee_common_callback_dispatcher.c zigbee_common_callback_dispatcher.h zigbee_ncp_callback_dispatcher.c zigbee_ncp_callback_dispatcher.h zigbee_stack_callback_dispatcher.c zigbee_stack_callback_dispatcher.h
  group Simplicity Configurator/autogen/.slc_state
    autogen/.slc_state/: .crc_config.crc
  group Simplicity Configurator/config
    config/: app_properties_config.h btl_interface_cfg.h dmadrv_config.h emlib_core_debug_config.h legacy_common_ash_config.h legacy_hal_config.h nvm3_default_config.h psa_crypto_config.h SEGGER_RTT_Conf.h sl_custom_manufacturing_token_header.h sl_custom_token_header.h sl_debug_swo_config.h sl_device_init_dcdc_config.h sl_device_init_emu_config.h sl_device_init_hfxo_config.h sl_iostream_usart_vcom_config.h sl_iostream_vuart_config.h sl_legacy_hal_wdog_config.h sl_mbedtls_config.h sl_mbedtls_device_config.h sl_memory_config.h sl_power_manager_config.h sl_rail_util_pa_config.h sl_rail_util_power_manager_init_config.h sl_rail_util_pti_config.h sl_rail_util_rssi_config.h sl_sleeptimer_config.h sl_token_manager_config.h sl_zigbee_debug_print_config.h sl_zigbee_green_power_config.h sl_zigbee_light_link_config.h sl_zigbee_pro_stack_config.h sl_zigbee_security_link_keys_config.h sl_zigbee_source_route_config.h tempdrv_config.h xncp_config.h zigbee_sleep_config.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/bootloader/api
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/bootloader/api/: application_properties.h btl_errorcode.h btl_interface.c btl_interface.h btl_interface_parser.h btl_interface_storage.c btl_interface_storage.h btl_reset_info.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/bootloader/app_properties
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/bootloader/app_properties/: app_properties.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/CMSIS/Core/Include
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h tz_context.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/common/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/common/inc/: sl_assert.h sl_atomic.h sl_common.h sl_endianness.h sl_enum.h sl_slist.h sl_status.h sl_string.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/common/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/common/src/: sl_assert.c sl_slist.c sl_string.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/common/toolchain/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/common/toolchain/inc/: sl_memory.h sl_memory_region.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/common/toolchain/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/common/toolchain/src/: sl_memory.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/Device/SiliconLabs/EFR32MG1B/Include
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/Device/SiliconLabs/EFR32MG1B/Include/: efr32mg1b232f256gm32.h efr32mg1b_acmp.h efr32mg1b_adc.h efr32mg1b_af_pins.h efr32mg1b_af_ports.h efr32mg1b_cmu.h efr32mg1b_cryotimer.h efr32mg1b_crypto.h efr32mg1b_devinfo.h efr32mg1b_dma_descriptor.h efr32mg1b_dmareq.h efr32mg1b_emu.h efr32mg1b_fpueh.h efr32mg1b_gpcrc.h efr32mg1b_gpio.h efr32mg1b_gpio_p.h efr32mg1b_i2c.h efr32mg1b_idac.h efr32mg1b_ldma.h efr32mg1b_ldma_ch.h efr32mg1b_letimer.h efr32mg1b_leuart.h efr32mg1b_msc.h efr32mg1b_pcnt.h efr32mg1b_prs.h efr32mg1b_prs_ch.h efr32mg1b_prs_signals.h efr32mg1b_rmu.h efr32mg1b_romtable.h efr32mg1b_rtcc.h efr32mg1b_rtcc_cc.h efr32mg1b_rtcc_ret.h efr32mg1b_timer.h efr32mg1b_timer_cc.h efr32mg1b_usart.h efr32mg1b_wdog.h efr32mg1b_wdog_pch.h em_device.h system_efr32mg1b.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/Device/SiliconLabs/EFR32MG1B/Source
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/Device/SiliconLabs/EFR32MG1B/Source/: startup_efr32mg1b.c system_efr32mg1b.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/driver/debug/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/driver/debug/inc/: sl_debug_swo.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/driver/debug/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/driver/debug/src/: sl_debug_swo.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/common/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/common/inc/: ecode.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/dmadrv/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/dmadrv/inc/: dmadrv.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/dmadrv/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/dmadrv/src/: dmadrv.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/nvm3/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/nvm3/inc/: nvm3.h nvm3_default.h nvm3_generic.h nvm3_hal.h nvm3_hal_flash.h nvm3_lock.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/nvm3/lib
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/nvm3/lib/: libnvm3_CM4_iar.a
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/nvm3/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/nvm3/src/: nvm3_default_common_linker.c nvm3_hal_flash.c nvm3_lock.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/tempdrv/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/tempdrv/inc/: tempdrv.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emdrv/tempdrv/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emdrv/tempdrv/src/: tempdrv.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emlib/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emlib/inc/: em_assert.h em_bus.h em_chip.h em_cmu.h em_cmu_compat.h em_common.h em_core.h em_core_generic.h em_crypto.h em_crypto_compat.h em_emu.h em_gpio.h em_ldma.h em_msc.h em_msc_compat.h em_prs.h em_ramfunc.h em_rmu.h em_rtcc.h em_system.h em_system_generic.h em_timer.h em_usart.h em_version.h em_wdog.h sli_em_cmu.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/emlib/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/emlib/src/: em_cmu.c em_core.c em_crypto.c em_emu.c em_gpio.c em_ldma.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/mac
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/mac/: indirect-queue.h lower-mac-debug.h lower-mac.h mac-child.h mac-command.h mac-flat-header.h mac-header.h mac-multi-network.h mac-packet-header.h mac-phy.h mac-types.h multi-mac.h scan.h upper-mac.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/mac/rail_mux
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/mac/rail_mux/: sl_rail_mux.h sl_rail_mux_rename.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/autogen/librail_release
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/autogen/librail_release/: librail_efr32xg1_iar_release.a
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/chip/efr32/efr32xg1x
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/chip/efr32/efr32xg1x/: rail_chip_specific.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/common
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/common/: rail.h rail_assert_error_codes.h rail_features.h rail_mfm.h rail_types.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/coexistence/common
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/coexistence/common/: coexistence.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154_uc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/coexistence/protocol/ieee802154_uc/: coexistence-802154.c coexistence-802154.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/pa-conversions
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/pa-conversions/: pa_conversions_efr32.c pa_conversions_efr32.h pa_curve_types_efr32.h pa_curves_efr32.c pa_curves_efr32.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/pa-conversions/efr32xg1x
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/pa-conversions/efr32xg1x/: sl_rail_util_pa_curves.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_ant_div
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_ant_div/: sl_rail_util_ant_div.c sl_rail_util_ant_div.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_ieee802154
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_ieee802154/: sl_rail_util_ieee802154_phy_select.h sl_rail_util_ieee802154_stack_event.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_power_manager_init
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_power_manager_init/: sl_rail_util_power_manager_init.c sl_rail_util_power_manager_init.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_pti
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_pti/: sl_rail_util_pti.c sl_rail_util_pti.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_rssi
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/plugin/rail_util_rssi/: sl_rail_util_rssi.c sl_rail_util_rssi.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/ble
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/ble/: rail_ble.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/ieee802154
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/ieee802154/: rail_ieee802154.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/sidewalk
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/sidewalk/: rail_sidewalk.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/wmbus
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/wmbus/: rail_wmbus.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/zwave
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/radio/rail_lib/protocol/zwave/: rail_zwave.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/security/sl_component/sl_mbedtls_support/config
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/security/sl_component/sl_mbedtls_support/config/: sli_mbedtls_acceleration.h sli_mbedtls_omnipresent.h sli_psa_acceleration.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/security/sl_component/sl_mbedtls_support/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/security/sl_component/sl_mbedtls_support/inc/: aes_alt.h ccm_alt.h cmac_alt.h gcm_alt.h sha1_alt.h sha256_alt.h sha512_alt.h sl_mbedtls.h sl_psa_values.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/security/sl_component/sl_mbedtls_support/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/security/sl_component/sl_mbedtls_support/src/: crypto_aes.c mbedtls_ccm.c sl_mbedtls.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/security/sl_component/sl_psa_driver/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/security/sl_component/sl_psa_driver/inc/: crypto_management.h sli_crypto_transparent_functions.h sli_crypto_transparent_types.h sli_psa_driver_common.h sli_psa_driver_features.h sli_se_version_dependencies.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/security/sl_component/sl_psa_driver/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/security/sl_component/sl_psa_driver/src/: crypto_management.c sli_crypto_transparent_driver_aead.c sli_crypto_transparent_driver_cipher.c sli_crypto_transparent_driver_hash.c sli_crypto_transparent_driver_mac.c sli_psa_driver_common.c sli_psa_driver_init.c sli_se_version_dependencies.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/device_init/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/device_init/inc/: sl_device_init_clocks.h sl_device_init_dcdc.h sl_device_init_emu.h sl_device_init_hfxo.h sl_device_init_nvic.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/device_init/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/device_init/src/: sl_device_init_dcdc_s1.c sl_device_init_emu_s1.c sl_device_init_hfxo_s1.c sl_device_init_nvic.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/iostream/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/iostream/inc/: sl_iostream.h sl_iostream_debug.h sl_iostream_swo.h sl_iostream_swo_itm_8.h sl_iostream_uart.h sl_iostream_usart.h sl_iostream_vuart.h sli_iostream_swo_itm_8.h sli_iostream_uart.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/iostream/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/iostream/src/: sl_iostream.c sl_iostream_debug.c sl_iostream_swo_itm_8.c sl_iostream_uart.c sl_iostream_usart.c sl_iostream_vuart.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_common_ash/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_common_ash/inc/: ash-common.h ash-protocol.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_common_ash/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_common_ash/src/: ash-common.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/: asm.h bootloader-eeprom.h bootloader-interface-app.h bootloader-interface.h button.h crc.h efm32_micro.h em2xx-reset-defs.h emlib_config.h hal.h interrupts-efm32.h led.h micro-common.h micro-types.h micro.h platform-header.h random.h reset-def.h serial.h sl_legacy_hal_integration_hooks.h token-manufacturing-series-1.h token-manufacturing-series-2.h token-manufacturing.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/cortexm3
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/cortexm3/: diagnostic.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/hal
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/hal/: hal.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/serial
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal/inc/serial/: serial.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal/src/: base-replacement.c crc.c diagnostic.c ember-phy.c faults.s random.c token_legacy.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal_wdog/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal_wdog/inc/: sl_legacy_hal_wdog.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_hal_wdog/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_hal_wdog/src/: sl_legacy_hal_wdog.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_ncp_ash/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_ncp_ash/inc/: ash-ncp.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_ncp_ash/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_ncp_ash/src/: ash-ncp.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_printf/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_printf/inc/: sl_legacy_printf.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/legacy_printf/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/legacy_printf/src/: sl_legacy_printf.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/power_manager/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/power_manager/inc/: sl_power_manager.h sl_power_manager_debug.h sli_power_manager.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/power_manager/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/power_manager/src/: sl_power_manager.c sl_power_manager_debug.c sl_power_manager_hal_s0_s1.c sli_power_manager_private.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/sleeptimer/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/sleeptimer/inc/: sl_sleeptimer.h sli_sleeptimer.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/sleeptimer/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_rtcc.c sl_sleeptimer_hal_timer.c sli_sleeptimer_hal.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/system/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/system/inc/: sl_system_init.h sl_system_process_action.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/system/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/system/src/: sl_system_init.c sl_system_process_action.c
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/token_manager/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/token_manager/inc/: sl_token_api.h sl_token_manager.h sl_token_manager_af_token_header.h sl_token_manufacturing.h sl_token_manufacturing_api.h sl_token_manufacturing_generic.h sl_token_manufacturing_series_1.h sl_token_manufacturing_series_2.h
  group Simplicity Configurator/gecko_sdk_4.4.6/platform/service/token_manager/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/platform/service/token_manager/src/: sl_token_def.c sl_token_manager.c sl_token_manufacturing.c sl_token_manufacturing_generic.c
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/em260
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/em260/: command-context.h command-handlers-binding-generated.c command-handlers-binding.h command-handlers-cbke.h command-handlers-green-power-generated.c command-handlers-messaging-generated.c command-handlers-mfglib-generated.c command-handlers-mfglib.h command-handlers-networking-generated.c command-handlers-security-generated.c command-handlers-security.h command-handlers-token-interface-generated.c command-handlers-token-interface.c command-handlers-trust-center-generated.c command-handlers-zigbee-pro.h command-handlers-zll-generated.c command-handlers-zll.h em260-callbacks.h em260-common.c ncp-stack-stub.c serial-interface-uart.c serial-interface.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/framework/common
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/framework/common/: zigbee_app_framework_callback.h zigbee_app_framework_common.c zigbee_app_framework_common.h zigbee_app_framework_event.h zigbee_app_framework_sleep.c zigbee_app_framework_stack_cb.c zigbee_enhanced_routing.c zigbee_ncp_framework_cb.c zigbee_token_interface.c zigbee_token_interface_stub.c
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/framework/plugin/debug-print
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/framework/plugin/debug-print/: sl_zigbee_debug_print.c sl_zigbee_debug_print.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/framework/util
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/framework/util/: af-ncp-token.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/ncp/plugin/xncp
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/ncp/plugin/xncp/: xncp.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/util/ezsp
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/util/ezsp/: ezsp-enum.h ezsp-frame-utilities.h ezsp-protocol.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/util/security
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/util/security/: security-address-cache.c security.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/app/xncp
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/app/xncp/: xncp-sample-custom-ezsp-protocol.h xncp-token.h xncp.h xncp_cb.c
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-gp-library/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-gp-library/release_singlenetwork/: libncp-gp-library.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-mfglib-library/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-mfglib-library/release_singlenetwork/: libncp-mfglib-library.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-pro-library/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-pro-library/release_singlenetwork/: libncp-pro-library.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-source-route-library/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-source-route-library/release_singlenetwork/: libncp-source-route-library.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-zll-library/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/ncp-zll-library/release_singlenetwork/: libncp-zll-library.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-debug-basic/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-debug-basic/release_singlenetwork/: libzigbee-debug-basic.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-debug-extended/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-debug-extended/release_singlenetwork/: libzigbee-debug-extended.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-gp/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-gp/release_singlenetwork/: libzigbee-gp.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-mfglib/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-mfglib/release_singlenetwork/: libzigbee-mfglib.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-ncp-uart/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-ncp-uart/release_singlenetwork/: libzigbee-ncp-uart.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-pro-stack/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-pro-stack/release_singlenetwork/: libzigbee-pro-stack.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-r22-support/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-r22-support/release_singlenetwork/: libzigbee-r22-support.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-source-route/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-source-route/release_singlenetwork/: libzigbee-source-route.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-xncp/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-xncp/release_singlenetwork/: libzigbee-xncp.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-zll/release_singlenetwork
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/build/iar/cortex-m4/zigbee-zll/release_singlenetwork/: libzigbee-zll.a
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/config
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/config/: config.h ember-configuration-access.c ember-configuration-defaults.h ember-configuration.c token-phy.h token-stack.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/core
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/core/: ember-multi-network-stub.c ember-multi-network.h multi-pan-common.c multi-pan-stub.c multi-pan-token-config.h multi-pan.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/framework
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/framework/: aes-ecb.c strong-random-api.c zigbee-debug-extended.h zigbee-event-logger-stub-gen.c zigbee_debug_channel.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/gp
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/gp/: gp-proxy-table.h gp-sink-table.h gp-token-config.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/include
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/include/: aes-mmo.h binding-table.h bootload.h byte-utilities.h cbke-crypto-engine.h child.h ember-alternate-mac.h ember-debug.h ember-duty-cycle.h ember-random-api.h ember-types-internal.h ember-types.h ember.h error-def.h error.h gp-types.h library.h mac-layer.h message.h mfglib.h multi-network.h multi-phy.h network-formation.h raw-message.h security.h sl_zigbee_address_info.h sl_zigbee_dynamic_commissioning.h sl_zigbee_tlv_core.h source-route.h stack-info.h trust-center.h zigbee-device-stack.h zigbee-event-logger-gen.h zigbee-security-manager-types.h zigbee-security-manager.h zll-api.h zll-types.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/mac
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/mac/: multi-mac.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/platform/micro
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/platform/micro/: aes.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/security
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/security/: cbke-crypto-engine-163k1-stub.c cbke-crypto-engine-283k1-stub.c cbke-crypto-engine-dsa-sign-stub.c cbke-crypto-engine-dsa-verify-283k1-stub.c cbke-crypto-engine-dsa-verify-stub.c cbke-crypto-engine-stub.c zigbee-security-manager-internal.h zigbee-security-manager-no-vault.c zigbee-security-manager-vault-support.h zigbee-security-manager.c
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/stubs
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/stubs/: sl_zigbee_dynamic_commissioning_stubs.c sl_zigbee_fragmentation_stubs.c sl_zigbee_r23_misc_support_stubs.c
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/zigbee
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/zigbee/: aps-keys-full.c aps-keys-full.h sli_zigbee_zdo_cluster_filter.c sli_zigbee_zdo_cluster_filter.h source-route-table-update.h
  group Simplicity Configurator/gecko_sdk_4.4.6/protocol/zigbee/stack/zll
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/protocol/zigbee/stack/zll/: zll-token-config.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/silicon_labs/silabs_core/buffer_manager
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/silicon_labs/silabs_core/buffer_manager/: buffer-management.h buffer-queue.h legacy-packet-buffer.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/silicon_labs/silabs_core/event_queue
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/silicon_labs/silabs_core/event_queue/: event-queue.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/silicon_labs/silabs_core/memory_manager
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/silicon_labs/silabs_core/memory_manager/: sl_malloc.c sl_malloc.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/mbedtls/include/mbedtls
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/mbedtls/include/psa
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/mbedtls/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/mbedtls/library
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/mbedtls/library/: aes.c alignment.h base64_internal.h bignum_core.h bignum_mod.h bignum_mod_raw.h bignum_mod_raw_invasive.h bn_mul.h ccm.c cipher.c cipher_wrap.c cipher_wrap.h common.h constant_time.c constant_time_impl.h constant_time_internal.h ecp_internal_alt.h ecp_invasive.h entropy_poll.h lmots.h md_psa.h md_wrap.h mps_common.h mps_error.h mps_reader.h mps_trace.h padlock.h pk_internal.h pk_wrap.h pkwrite.h platform.c platform_util.c psa_crypto_client.c psa_util.c psa_util_internal.h rsa_alt_helpers.h ssl_client.h ssl_debug_helpers.h ssl_misc.h ssl_tls13_invasive.h ssl_tls13_keys.h threading.c
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/printf
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/printf/: printf.c printf.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/printf/inc
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/printf/inc/: iostream_printf.h
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/printf/src
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/printf/src/: iostream_printf.c
  group Simplicity Configurator/gecko_sdk_4.4.6/util/third_party/segger/systemview/SEGGER
    C:/SiliconLabs/SimplicityStudio/v5/offline/sdk/gecko_sdk_4.4.6/util/third_party/segger/systemview/SEGGER/: SEGGER.h SEGGER_RTT.c SEGGER_RTT.h
